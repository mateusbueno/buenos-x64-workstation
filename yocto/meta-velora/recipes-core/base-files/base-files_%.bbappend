# Story 6.11: read-only root. Writable runtime paths are tmpfs. /run and /var/volatile come from the stock base-files fstab;
# /tmp is made explicit here (systemd's tmp.mount would also do it, but the fstab line makes the policy visible and testable).
do_install:append() {
    echo "tmpfs                /tmp                 tmpfs      mode=1777,nodev,nosuid,size=64m   0  0" >> ${D}${sysconfdir}/fstab
    # mount point of the persistent partition (the fstab line itself is generated by wic from velora-nvme.wks)
    install -d ${D}/data
}
FILES:${PN} += "/data"
